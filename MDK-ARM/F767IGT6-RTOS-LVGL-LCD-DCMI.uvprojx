# Keil uVision project F767IGT6-RTOS-LVGL-LCD-DCMI.uvprojx, settings and files
target F767IGT6-RTOS-LVGL-LCD-DCMI (6240000::V6.24::ARMCLANG)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: F767IGT6-RTOS-LVGL-LCD-DCMI +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F767xx
  c include: ../Core/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../Drivers/CMSIS/Include;../FreeRTOS/Source/include;../FreeRTOS/Source/portable/GCC/ARM_CM7/r0p1;../FreeRTOS/Config;../App;../LVGL;../LVGL/lvgl;../LVGL/lvgl/include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32f767xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dcmi.c dma2d.c fmc.c ltdc.c quadspi.c usart.c stm32f7xx_it.c stm32f7xx_hal_msp.c stm32f7xx_hal_timebase_tim.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_dma2d.c stm32f7xx_ll_fmc.c stm32f7xx_hal_nor.c stm32f7xx_hal_sram.c stm32f7xx_hal_nand.c stm32f7xx_hal_sdram.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_qspi.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
  group Middleware/FreeRTOS
    ../FreeRTOS/Source/: tasks.c queue.c list.c timers.c event_groups.c stream_buffer.c
    ../FreeRTOS/Source/portable/GCC/ARM_CM7/r0p1/: port.c
    ../FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../FreeRTOS/Config/: FreeRTOSConfig.h
  group App
    ../App/: app_tasks.c app_config.h
    ../App/led/: app_led.c
    ../App/uart/: app_uart.c
    ../App/lvgl/: app_lvgl.c app_font_cn_14.c
    ../App/touch/: touch_detect.c touch_detect.h touch_pins.h
    ../App/camera/: app_camera.c camera_util.c sccb.c pcf8574.c ov5640.c app_camera.h camera_util.h sccb.h pcf8574.h ov5640.h ov5640cfg.h
  group Middleware/LVGL
    ../LVGL/: lv_port_disp.c lv_port_indev.c lv_conf.h
    ../LVGL/lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_observer.c lv_refr.c
    ../LVGL/lvgl/src/debugging/monkey/: lv_monkey.c
    ../LVGL/lvgl/src/debugging/profiler/: lv_profiler_builtin.c lv_profiler_builtin_posix.c
    ../LVGL/lvgl/src/debugging/sysmon/: lv_sysmon.c
    ../LVGL/lvgl/src/debugging/test/: lv_test_display.c lv_test_display_egl.c lv_test_fs.c lv_test_helpers.c lv_test_indev.c lv_test_indev_gesture.c lv_test_screenshot_compare.c
    ../LVGL/lvgl/src/debugging/vg_lite_tvg/: vg_lite_matrix.c
    ../LVGL/lvgl/src/display/: lv_display.c
    ../LVGL/lvgl/src/draw/convert/helium/: lv_draw_buf_convert_helium.c
    ../LVGL/lvgl/src/draw/convert/: lv_draw_buf_convert.c
    ../LVGL/lvgl/src/draw/convert/neon/: lv_draw_buf_convert_neon.c
    ../LVGL/lvgl/src/draw/dma2d/: lv_draw_dma2d.c lv_draw_dma2d_fill.c lv_draw_dma2d_img.c
    ../LVGL/lvgl/src/draw/espressif/ppa/: lv_draw_ppa.c lv_draw_ppa_buf.c lv_draw_ppa_fill.c lv_draw_ppa_img.c
    ../LVGL/lvgl/src/draw/eve/: lv_draw_eve.c lv_draw_eve_arc.c lv_draw_eve_fill.c lv_draw_eve_image.c lv_draw_eve_letter.c lv_draw_eve_line.c lv_draw_eve_ram_g.c lv_draw_eve_triangle.c lv_eve.c
    ../LVGL/lvgl/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_blur.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_utils.c lv_draw_vector.c
    ../LVGL/lvgl/src/draw/nanovg/: lv_draw_nanovg.c lv_draw_nanovg_3d.c lv_draw_nanovg_arc.c lv_draw_nanovg_blur.c lv_draw_nanovg_border.c lv_draw_nanovg_box_shadow.c lv_draw_nanovg_fill.c lv_draw_nanovg_grad.c lv_draw_nanovg_image.c lv_draw_nanovg_label.c lv_draw_nanovg_layer.c lv_draw_nanovg_line.c lv_draw_nanovg_mask_rect.c lv_draw_nanovg_triangle.c lv_draw_nanovg_vector.c lv_nanovg_fbo_cache.c lv_nanovg_image_cache.c lv_nanovg_utils.c
    ../LVGL/lvgl/src/draw/nema_gfx/: lv_draw_nema_gfx.c lv_draw_nema_gfx_arc.c lv_draw_nema_gfx_border.c lv_draw_nema_gfx_cache.c lv_draw_nema_gfx_fill.c lv_draw_nema_gfx_img.c lv_draw_nema_gfx_label.c lv_draw_nema_gfx_layer.c lv_draw_nema_gfx_line.c lv_draw_nema_gfx_stm32_hal.c lv_draw_nema_gfx_triangle.c lv_draw_nema_gfx_utils.c lv_draw_nema_gfx_vector.c lv_nema_gfx_path.c
    ../LVGL/lvgl/src/draw/nxp/g2d/: lv_draw_buf_g2d.c lv_draw_g2d.c lv_draw_g2d_fill.c lv_draw_g2d_img.c lv_g2d_buf_map.c lv_g2d_utils.c
    ../LVGL/lvgl/src/draw/nxp/pxp/: lv_draw_buf_pxp.c lv_draw_pxp.c lv_draw_pxp_fill.c lv_draw_pxp_img.c lv_draw_pxp_layer.c lv_pxp_cfg.c lv_pxp_osa.c lv_pxp_utils.c
    ../LVGL/lvgl/src/draw/opengles/: lv_draw_opengles.c
    ../LVGL/lvgl/src/draw/renesas/dave2d/: lv_draw_dave2d.c lv_draw_dave2d_arc.c lv_draw_dave2d_border.c lv_draw_dave2d_fill.c lv_draw_dave2d_image.c lv_draw_dave2d_label.c lv_draw_dave2d_line.c lv_draw_dave2d_mask_rectangle.c lv_draw_dave2d_triangle.c lv_draw_dave2d_utils.c
    ../LVGL/lvgl/src/draw/sdl/: lv_draw_sdl.c
    ../LVGL/lvgl/src/draw/sifli/epic/: lv_draw_buf_sifli_epic.c lv_draw_sifli_epic.c lv_draw_sifli_epic_border.c lv_draw_sifli_epic_fill.c lv_draw_sifli_epic_img.c lv_draw_sifli_epic_label.c lv_draw_sifli_epic_layer.c lv_sifli_epic_cfg.c lv_sifli_epic_osa.c lv_sifli_epic_utils.c
    ../LVGL/lvgl/src/draw/snapshot/: lv_snapshot.c
    ../LVGL/lvgl/src/draw/sw/blend/arm2d/: lv_blend_arm2d.c
    ../LVGL/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_a8.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
    ../LVGL/lvgl/src/draw/sw/blend/neon/: lv_draw_sw_blend_neon_to_rgb565.c lv_draw_sw_blend_neon_to_rgb888.c
    ../LVGL/lvgl/src/draw/sw/blend/riscv_v/: lv_draw_sw_blend_riscv_v_to_rgb888.c
    ../LVGL/lvgl/src/draw/sw/blend/sve2/: lv_draw_sw_blend_sve2_to_rgb888.c
    ../LVGL/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blur.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_vector.c
    ../LVGL/lvgl/src/draw/vg_lite/: lv_draw_buf_vg_lite.c lv_draw_vg_lite.c lv_draw_vg_lite_arc.c lv_draw_vg_lite_border.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_img.c lv_draw_vg_lite_label.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_line.c lv_draw_vg_lite_mask_rect.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_vector.c lv_vg_lite_bitmap_font_cache.c lv_vg_lite_decoder.c lv_vg_lite_grad.c lv_vg_lite_math.c lv_vg_lite_path.c lv_vg_lite_pending.c lv_vg_lite_stroke.c lv_vg_lite_utils.c
    ../LVGL/lvgl/src/drivers/display/drm/: lv_linux_drm.c lv_linux_drm_common.c lv_linux_drm_egl.c
    ../LVGL/lvgl/src/drivers/display/fb/: lv_linux_fbdev.c
    ../LVGL/lvgl/src/drivers/display/ft81x/: lv_ft81x.c
    ../LVGL/lvgl/src/drivers/display/mipi/: lv_ili9341.c lv_lcd_generic_mipi.c lv_nv3007.c lv_st7735.c lv_st7789.c lv_st7796.c
    ../LVGL/lvgl/src/drivers/display/nxp_elcdif/: lv_nxp_elcdif.c
    ../LVGL/lvgl/src/drivers/display/renesas_glcdc/: lv_renesas_glcdc.c
    ../LVGL/lvgl/src/drivers/display/st_ltdc/: lv_st_ltdc.c
    ../LVGL/lvgl/src/drivers/draw/eve/: lv_draw_eve_display.c
    ../LVGL/lvgl/src/drivers/evdev/: lv_evdev.c
    ../LVGL/lvgl/src/drivers/libinput/: lv_libinput.c lv_xkb.c
    ../LVGL/lvgl/src/drivers/nuttx/: lv_nuttx_cache.c lv_nuttx_entry.c lv_nuttx_fbdev.c lv_nuttx_image_cache.c lv_nuttx_lcd.c lv_nuttx_libuv.c lv_nuttx_mouse.c lv_nuttx_profiler.c lv_nuttx_touchscreen.c
    ../LVGL/lvgl/src/drivers/opengles/assets/: lv_opengles_shader.c
    ../LVGL/lvgl/src/drivers/opengles/glad/src/: egl.c gl.c gles2.c
    ../LVGL/lvgl/src/drivers/opengles/: lv_opengles_debug.c lv_opengles_driver.c lv_opengles_egl.c lv_opengles_glfw.c lv_opengles_pbuffer.c lv_opengles_texture.c
    ../LVGL/lvgl/src/drivers/opengles/opengl_shader/: lv_opengl_shader_manager.c lv_opengl_shader_program.c
    ../LVGL/lvgl/src/drivers/qnx/: lv_qnx.c
    ../LVGL/lvgl/src/drivers/sdl/: lv_sdl_egl.c lv_sdl_keyboard.c lv_sdl_mouse.c lv_sdl_mousewheel.c lv_sdl_sw.c lv_sdl_texture.c lv_sdl_window.c
    ../LVGL/lvgl/src/drivers/uefi/: lv_uefi_context.c lv_uefi_display.c lv_uefi_indev_keyboard.c lv_uefi_indev_pointer.c lv_uefi_indev_touch.c lv_uefi_private.c
    ../LVGL/lvgl/src/drivers/wayland/: lv_wayland.c lv_wayland_backend.c lv_wayland_backend_dmabuf.c lv_wayland_backend_egl.c lv_wayland_backend_g2d.c lv_wayland_backend_shm.c lv_wayland_dmabuf.c lv_wayland_keyboard.c lv_wayland_pointer.c lv_wayland_seat.c lv_wayland_touch.c lv_wayland_window.c lv_wayland_xdg_shell.c
    ../LVGL/lvgl/src/drivers/windows/: lv_windows_context.c lv_windows_display.c lv_windows_input.c
    ../LVGL/lvgl/src/drivers/x11/: lv_x11_display.c lv_x11_input.c
    ../LVGL/lvgl/src/font/binfont_loader/: lv_binfont_loader.c
    ../LVGL/lvgl/src/font/fmt_txt/: lv_font_fmt_txt.c
    ../LVGL/lvgl/src/font/font_manager/: lv_font_manager.c lv_font_manager_recycle.c
    ../LVGL/lvgl/src/font/freetype/: lv_freetype.c lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_ftsystem.c
    ../LVGL/lvgl/src/font/imgfont/: lv_imgfont.c
    ../LVGL/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    ../LVGL/lvgl/src/font/tiny_ttf/: lv_tiny_ttf.c
    ../LVGL/lvgl/src/fs/: lv_fs.c lv_fs_fatfs.c lv_fs_frogfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_uefi.c lv_fs_win32.c
    ../LVGL/lvgl/src/image/: lv_bin_decoder.c lv_bmp.c lv_image_decoder.c lv_libjpeg_turbo.c lv_libpng.c lv_libwebp.c lv_lodepng.c lv_tjpgd.c
    ../LVGL/lvgl/src/image/svg/: lv_svg.c lv_svg_decoder.c lv_svg_parser.c lv_svg_render.c lv_svg_token.c
    ../LVGL/lvgl/src/indev/: lv_gridnav.c lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
    ../LVGL/lvgl/src/layouts/flex/: lv_flex.c
    ../LVGL/lvgl/src/layouts/grid/: lv_grid.c
    ../LVGL/lvgl/src/layouts/: lv_layout.c
    ../LVGL/lvgl/src/libs/barcode/: code128.c
    ../LVGL/lvgl/src/libs/frogfs/src/: decomp_raw.c frogfs.c
    ../LVGL/lvgl/src/libs/FT800-FT813/: EVE_commands.c EVE_supplemental.c
    ../LVGL/lvgl/src/libs/gif/: gif.c
    ../LVGL/lvgl/src/libs/gltf/gltf_data/: lv_gltf_model_loader.c
    ../LVGL/lvgl/src/libs/gltf/gltf_environment/: lv_gltf_ibl_sampler.c
    ../LVGL/lvgl/src/libs/gltf/gltf_view/assets/: chromatic.c lv_gltf_view_shader.c
    ../LVGL/lvgl/src/libs/gltf/math/: lv_3dmath.c
    ../LVGL/lvgl/src/libs/lodepng/: lodepng.c
    ../LVGL/lvgl/src/libs/lz4/: lz4.c
    ../LVGL/lvgl/src/libs/nanovg/: nanovg.c
    ../LVGL/lvgl/src/libs/qrcode/: qrcodegen.c
    ../LVGL/lvgl/src/libs/rle/: lv_rle.c
    ../LVGL/lvgl/src/libs/rlottie/: lv_rlottie.c
    ../LVGL/lvgl/src/libs/tjpgd/: tjpgd.c
    ../LVGL/lvgl/src/libs/vg_lite_driver/lv_vg_lite_hal/: lv_vg_lite_hal.c vg_lite_os.c
    ../LVGL/lvgl/src/libs/vg_lite_driver/VGLite/: vg_lite.c vg_lite_image.c vg_lite_matrix.c vg_lite_path.c vg_lite_stroke.c
    ../LVGL/lvgl/src/libs/vg_lite_driver/VGLiteKernel/: vg_lite_kernel.c
    ../LVGL/lvgl/src/logging/: lv_log.c
    ../LVGL/lvgl/src/: lv_init.c
    ../LVGL/lvgl/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
    ../LVGL/lvgl/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../LVGL/lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ../LVGL/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_bidi_common.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_grad.c lv_iter.c lv_ll.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_pending.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ../LVGL/lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_linux.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_sdl2.c lv_windows.c
    ../LVGL/lvgl/src/others/file_explorer/: lv_file_explorer.c
    ../LVGL/lvgl/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../LVGL/lvgl/src/others/translation/: lv_translation.c
    ../LVGL/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../LVGL/lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../LVGL/lvgl/src/stdlib/: lv_mem.c
    ../LVGL/lvgl/src/stdlib/micropython/: lv_mem_core_micropython.c
    ../LVGL/lvgl/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
    ../LVGL/lvgl/src/stdlib/uefi/: lv_mem_core_uefi.c
    ../LVGL/lvgl/src/themes/default/: lv_theme_default.c
    ../LVGL/lvgl/src/themes/: lv_theme.c
    ../LVGL/lvgl/src/themes/mono/: lv_theme_mono.c
    ../LVGL/lvgl/src/themes/simple/: lv_theme_simple.c
    ../LVGL/lvgl/src/tick/: lv_tick.c
    ../LVGL/lvgl/src/widgets/3dtexture/: lv_3dtexture.c
    ../LVGL/lvgl/src/widgets/animimage/: lv_animimage.c
    ../LVGL/lvgl/src/widgets/arc/: lv_arc.c
    ../LVGL/lvgl/src/widgets/arclabel/: lv_arclabel.c
    ../LVGL/lvgl/src/widgets/bar/: lv_bar.c
    ../LVGL/lvgl/src/widgets/barcode/: lv_barcode.c
    ../LVGL/lvgl/src/widgets/button/: lv_button.c
    ../LVGL/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../LVGL/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../LVGL/lvgl/src/widgets/canvas/: lv_canvas.c
    ../LVGL/lvgl/src/widgets/chart/: lv_chart.c
    ../LVGL/lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../LVGL/lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../LVGL/lvgl/src/widgets/ffmpeg/: lv_ffmpeg.c
    ../LVGL/lvgl/src/widgets/gif/: lv_gif.c
    ../LVGL/lvgl/src/widgets/gstreamer/: lv_gstreamer.c
    ../LVGL/lvgl/src/widgets/image/: lv_image.c
    ../LVGL/lvgl/src/widgets/imagebutton/: lv_imagebutton.c
    ../LVGL/lvgl/src/widgets/ime/: lv_ime_pinyin.c
    ../LVGL/lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../LVGL/lvgl/src/widgets/label/: lv_label.c
    ../LVGL/lvgl/src/widgets/led/: lv_led.c
    ../LVGL/lvgl/src/widgets/line/: lv_line.c
    ../LVGL/lvgl/src/widgets/list/: lv_list.c
    ../LVGL/lvgl/src/widgets/lottie/: lv_lottie.c
    ../LVGL/lvgl/src/widgets/menu/: lv_menu.c
    ../LVGL/lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../LVGL/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../LVGL/lvgl/src/widgets/property/: lv_animimage_properties.c lv_arc_properties.c lv_bar_properties.c lv_buttonmatrix_properties.c lv_chart_properties.c lv_checkbox_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_led_properties.c lv_line_properties.c lv_menu_properties.c lv_obj_properties.c lv_roller_properties.c lv_scale_properties.c lv_slider_properties.c lv_span_properties.c lv_spinbox_properties.c lv_spinner_properties.c lv_style_properties.c lv_switch_properties.c lv_table_properties.c lv_tabview_properties.c lv_textarea_properties.c
    ../LVGL/lvgl/src/widgets/qrcode/: lv_qrcode.c
    ../LVGL/lvgl/src/widgets/roller/: lv_roller.c
    ../LVGL/lvgl/src/widgets/scale/: lv_scale.c
    ../LVGL/lvgl/src/widgets/slider/: lv_slider.c
    ../LVGL/lvgl/src/widgets/span/: lv_span.c
    ../LVGL/lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../LVGL/lvgl/src/widgets/spinner/: lv_spinner.c
    ../LVGL/lvgl/src/widgets/switch/: lv_switch.c
    ../LVGL/lvgl/src/widgets/table/: lv_table.c
    ../LVGL/lvgl/src/widgets/tabview/: lv_tabview.c
    ../LVGL/lvgl/src/widgets/textarea/: lv_textarea.c
    ../LVGL/lvgl/src/widgets/tileview/: lv_tileview.c
    ../LVGL/lvgl/src/widgets/win/: lv_win.c
software components: CMSIS:CORE 6.1.1
